options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fecapi_encoders
    output_language: python
  states: {}

blocks:
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    framebits: frame_size*8
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc_ccsds
  id: variable_ccsds_encoder_def
  parameters:
    framebits: frame_size*8
    mode: fec.CC_TERMINATED
    ndim: '0'
    state_start: '0'
  states: {}
- name: enc_dummy
  id: variable_dummy_encoder_def
  parameters:
    framebits: frame_size*8
    ndim: '0'
  states: {}
- name: enc_rep
  id: variable_repetition_encoder_def
  parameters:
    dim1: '1'
    framebits: frame_size*8
    ndim: '1'
    rep: '3'
  states: {}
- name: enc_turbo
  id: variable_turbo_encoder_def
  parameters:
    dim1: '1'
    dim2: '1'
    framebits: '480'
    ndim: '0'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (frame_size//15)*[0, 0, 1, 0, 3, 0, 7, 0, 15, 0, 31, 0, 63, 0, 127]
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: enc_cc
    puncpat: puncpat
    threadtype: none
  states: {state: disabled}
- name: fec_extended_encoder_0_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: enc_turbo
    puncpat: puncpat
    threadtype: none
  states: {}
- name: fec_extended_encoder_1
  id: fec_extended_encoder
  parameters:
    encoder_list: enc_ccsds
    puncpat: puncpat
    threadtype: none
  states: {state: disabled}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '60'
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '0.6'
    label1: CCSDS
    label2: CC
    nconnections: '2'
    size: '2048'
    srate: samp_rate
    type: float
    update_time: '0.05'
    ymax: '1.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: Rep (x3)
    size: '2048'
    srate: samp_rate
    tr_tag: packet_len
    type: float
    update_time: '0.05'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_1_0_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_throttle2_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_throttle_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_1, '0']
- [blocks_vector_source_x_0_1_0, '0', blocks_throttle2_0, '0']
- [blocks_vector_source_x_0_1_0, '0', blocks_throttle_0, '0']
- [fec_extended_encoder_0, '0', blocks_char_to_float_1, '0']
- [fec_extended_encoder_0_0_0, '0', blocks_char_to_float_1_0_0, '0']
- [fec_extended_encoder_1, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: gac2244fa1
