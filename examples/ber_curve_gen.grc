options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ber_curve_gen
    output_language: python
  states: {}

blocks:
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    framebits: framebits
    k: k
    mode: fec.CC_STREAMING
    ndim: '2'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_dummy
  id: variable_dummy_decoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    framebits: framebits
    ndim: '2'
  states: {}
- name: dec_ldpc
  id: variable_ldpc_decoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    file: gr.prefix() + "/share/gnuradio/fec/ldpc/271.127.3.112"
    max_iter: '50'
    ndim: '2'
  states: {}
- name: dec_rep
  id: variable_repetition_decoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    framebits: framebits
    ndim: '2'
    prob: '0.5'
    rep: '3'
  states: {}
- name: dec_tpc
  id: variable_tpc_decoder_def
  parameters:
    bval: '9'
    col_poly: '[43]'
    decoder_type: '1'
    dim1: len(esno_0)
    dim2: '1'
    kcol: '6'
    krow: '26'
    max_iter: '6'
    ndim: '2'
    qval: '3'
    row_poly: '[3]'
  states: {}
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    framebits: framebits
    k: k
    mode: fec.CC_STREAMING
    ndim: '2'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc_dummy
  id: variable_dummy_encoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    framebits: framebits
    ndim: '2'
  states: {}
- name: enc_ldpc
  id: variable_ldpc_encoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    file: gr.prefix() + "/share/gnuradio/fec/ldpc/271.127.3.112"
    ndim: '2'
  states: {}
- name: enc_rep
  id: variable_repetition_encoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    framebits: framebits
    ndim: '2'
    rep: '3'
  states: {}
- name: enc_tpc
  id: variable_tpc_encoder_def
  parameters:
    bval: '9'
    col_poly: '[43]'
    dim1: len(esno_0)
    dim2: '1'
    kcol: '6'
    krow: '26'
    ndim: '2'
    qval: '3'
    row_poly: '[3]'
  states: {}
- name: esno
  id: variable
  parameters:
    value: esno_0
  states: {}
- name: esno_0
  id: variable
  parameters:
    value: 'numpy.arange(0, 8, .5) '
  states: {}
- name: framebits
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: num_curves
  id: variable
  parameters:
    value: '5'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[79, 109]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '35000000'
  states: {}
- name: fec_bercurve_generator_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_cc
    encoder_list: enc_cc
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: fec_bercurve_generator_0_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_rep
    encoder_list: enc_rep
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: fec_bercurve_generator_0_0_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_dummy
    encoder_list: enc_dummy
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: fec_bercurve_generator_0_1
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_ldpc
    encoder_list: enc_ldpc
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: fec_bercurve_generator_0_1_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_tpc
    encoder_list: enc_tpc
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    alpha1: '1'
    alpha2: '1'
    alpha3: '1'
    berlimit: '-10'
    berminerrors: '1000'
    color3: '"magenta"'
    color4: '"dark red"'
    color5: '"Dark Blue"'
    esno: esno_0
    label1: None
    label2: Rep. (Rate=3)
    label3: CC (K=7, Rate=2)
    label4: LDPC
    label5: TPC
    marker2: '1'
    num_curves: '5'
    style2: '2'
    style3: '5'
    style4: '5'
    style5: '4'
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    width5: '2'
  states: {bus_sink: true}

connections:
- [fec_bercurve_generator_0, '32', qtgui_bercurve_sink_0, '162']
- [fec_bercurve_generator_0_0, '32', qtgui_bercurve_sink_0, '161']
- [fec_bercurve_generator_0_0_0, '32', qtgui_bercurve_sink_0, '160']
- [fec_bercurve_generator_0_1, '32', qtgui_bercurve_sink_0, '163']
- [fec_bercurve_generator_0_1_0, '32', qtgui_bercurve_sink_0, '164']

metadata:
  file_format: 1
  grc_version: gac2244fa1
